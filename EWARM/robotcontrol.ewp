# IAR project robotcontrol.ewp, settings and files
configuration robotcontrol (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; D:\YLS\robotcontrol - 05.12\HARDWARE\Ethercat; D:\YLS\robotcontrol - 05.12\HARDWARE\W25QXX; D:\YLS\robotcontrol - 05.12\HARDWARE\WK2124; D:\YLS\robotcontrol - 05.12\MOTOR2
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: robotcontrol.hex
  ILINK.IlinkOutputFile: robotcontrol.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/MOTOR2
    ../MOTOR2/: motor.c motor_it.c MotorStart.c
  group Application/User/Core
    ../Core/Src/: bsp_MOTOR1.c bsp_MOTOR2.c bsp_MOTOR3.c bsp_MOTOR4.c bsp_MOTOR5.c bsp_MOTOR6.c com1_232.c com2_232.c com3_232.c com4_232.c com5_232.c com6_232.c DoWith.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c wk_port1.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group HARDWARE
    ../HARDWARE/Ethercat/: ecm_opcmd.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/WK2124/: wk2xxx.c
